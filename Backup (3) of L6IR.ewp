# IAR project Backup (3) of L6IR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZC ST STM32L152ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; L6IR_CU; L6IR; nL7IR; LPS331AP; A3G4250D; PT2_MODE; nTNV_MODE; nPT7_MODE; nTABLE_BAL; nFR11059200; FR14745600; nMETEO; nTEST_MODE; nRFU; nPT7_DEFAULT; PT8_DEFAULT; nPT9_DEFAULT; nSWIR_DEFAULT
  ICCARM.CCIncludePath2: CMSIS\Device\ST\STM32L1xx; CMSIS\Device\ST\STM32L1xx\Include; mcu; $PROJ_DIR$; rfu_stm32\include; init\debug; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0\arm\CMSIS\Include; nCMSIS\CM3\CoreSupport; mcu\inc; STM32L1xx_StdPeriph_Driver\inc; ..\..\src\MicroXplorer\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L6IR.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32l152xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; FR14745600; nFR11059200; L6IR_CU; nPT2_MODE; PT7_MODE; nTABLE_BAL; nTNM_MODE; nSWIR_MODE; nA3G4250D; nLPS331AP; METEO; nTEST_MODE; nFLASH_ENABLE
  ICCARM.CCIncludePath2: E:\projects\L6IR\programm\L6_pro\STM32L1xx_StdPeriph_Driver\src; E:\projects\L6IR\programm\L6_pro\STM32L1xx_StdPeriph_Driver\inc; E:\projects\L6IR\programm\L6_pro\mcu; E:\projects\L6IR\programm\L6_pro\mcu\inc; nE:\projects\L6IR\programm\L6_pro\CMSIS\CM3\CoreSupport; E:\projects\L6IR\programm\L6_pro\CMSIS\Device\ST\STM32L1xx\Include; E:\projects\L6IR\programm\L6_pro\mcu\startup\iar; E:\projects\L6IR\programm\L6_pro\rfu_stm32\include; E:\projects\L6IR\programm\L6_pro\rfu_stm32\source; E:\projects\L6IR\programm\L6_pro\CMSIS\Include; E:\projects\L6IR\programm\L6_pro
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: E:\projects\L6IR\programm\L6_pro\stm32l1xx_flash.icf
  group (top)
    ./: led_control.c main.c net.c system_init.c
    CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
  group Ballistic
    ./: Ball.cpp
  group Camera
    ./: Camera.c Camera_tasks.c default_flash_content.c default_flash_content_PT7.c default_flash_content_PT8.c default_flash_content_PT9.c
  group mcu
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c
    mcu/: stm32l1xx_it.c system_timer.c
    CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group protocols
    ./: protocol_cu.c protocol_L6IR.c protocol_L6IR_encoder_new.c protocol_L6IR_encoder_old.c
  group rfu
    rfu_stm32/source/: rfu.c rfu_ram.c rfu_stm32L10x.c
  group Sensors
    ./: a3g4250d.c A3G4250D_driver.c i2c.c I2CRoutines.c lps331ap.c lps331ap_driver.c LSM6DS33.c operator_control.c Sensors.c
    STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c
  group Settings
    ./: settings.c
  group special
    ./: Buffer.cpp cbuf.c keys.c
  group TNM
    ./: digital_resist.c galenic.c
